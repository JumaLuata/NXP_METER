# IAR project bm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 NXP MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW41Z512VHT4; FRDM_KW41Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.PreInclude: source/app_preinclude.h
  ICCARM.CCIncludePath2: CMSIS; bluetooth/controller/interface; bluetooth/hci_transport/interface; bluetooth/host/config; bluetooth/host/interface; bluetooth/profiles/battery; bluetooth/profiles/device_info; bluetooth/profiles/wireless_uart; board; doc; drivers; framework/DCDC/Interface; framework/Flash/Internal; framework/FunctionLib; framework/GPIO; framework/Keyboard/Interface; framework/LED/Interface; framework/Lists; framework/MWSCoexistence/Interface; framework/MemManager/Interface; framework/Messaging/Interface; framework/ModuleInfo; framework/NVM/Interface; framework/NVM/Source; framework/OSAbstraction/Interface; framework/Panic/Interface; framework/RNG/Interface; framework/SecLib; framework/SerialManager/Interface; framework/SerialManager/Source/I2C_Adapter; framework/SerialManager/Source/SPI_Adapter; framework/SerialManager/Source/UART_Adapter; framework/Shell/Interface; framework/TimersManager/Interface; framework/TimersManager/Source; framework/XCVR/MKW41Z4; framework/common; source; source/common; source/common/gatt_db; source/common/gatt_db/macros; utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: wireless_uart_frdmkw41z.bin
  ILINK.IlinkOutputFile: bm.out
  ILINK.IlinkConfigDefines: gUseNVMLink_d=1
  ILINK.IlinkIcfFile: MKW41Z512xxx4_connectivity.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKW41Z512VHT4; FRDM_KW41Z; FREEDOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ./: lib_ble_4-2_host_cm0p.a lib_ble_kw41z_controller.a lib_crypto_m0.a
  group bluetooth/controller/interface
    bluetooth/controller/interface/: controller_interface.h
  group bluetooth/hci_transport/interface
    bluetooth/hci_transport/interface/: hci_transport.h
  group bluetooth/hci_transport/source
    bluetooth/hci_transport/source/: hcit_serial_interface.c
  group bluetooth/host/config
    bluetooth/host/config/: ble_config.h ble_globals.c
  group bluetooth/host/interface
    bluetooth/host/interface/: att_callbacks.h att_errors.h att_interface.h att_params.h att_types.h ble_constants.h ble_general.h ble_host_tasks.h ble_sig_defines.h ble_utils.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_db_dynamic.h gatt_interface.h gatt_server_interface.h gatt_types.h hci_interface.h hci_types.h l2ca_cb_interface.h l2ca_interface.h l2ca_types.h vendor_debug_commands.h
  group bluetooth/profiles/battery
    bluetooth/profiles/battery/: battery_interface.h battery_service.c
  group bluetooth/profiles/device_info
    bluetooth/profiles/device_info/: device_info_interface.h device_info_service.c
  group bluetooth/profiles/wireless_uart
    bluetooth/profiles/wireless_uart/: wireless_uart_interface.h wireless_uart_service.c
  group board
    board/: board.c board.h clock_config.c clock_config.h gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0plus.h core_cmFunc.h core_cmInstr.h core_cmSimd.h fsl_device_registers.h MKW41Z4.h MKW41Z4_features.h system_MKW41Z4.c system_MKW41Z4.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dspi.c fsl_dspi.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_ltc.c fsl_ltc.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rtc.c fsl_rtc.h fsl_smc.c fsl_smc.h fsl_tpm.c fsl_tpm.h fsl_trng.c fsl_trng.h
  group framework/common
    framework/common/: EmbeddedTypes.h
  group framework/DCDC/Interface
    framework/DCDC/Interface/: DCDC.h
  group framework/DCDC/Source
    framework/DCDC/Source/: DCDC.c
  group framework/Flash/Internal
    framework/Flash/Internal/: Flash_Adapter.c Flash_Adapter.h
  group framework/FunctionLib
    framework/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/GPIO
    framework/GPIO/: GPIO_Adapter.c GPIO_Adapter.h
  group framework/Keyboard/Interface
    framework/Keyboard/Interface/: Keyboard.h
  group framework/Keyboard/Source
    framework/Keyboard/Source/: Keyboard.c
  group framework/LED/Interface
    framework/LED/Interface/: LED.h
  group framework/LED/Source
    framework/LED/Source/: LED.c
  group framework/Lists
    framework/Lists/: GenericList.c GenericList.h
  group framework/MemManager/Interface
    framework/MemManager/Interface/: MemManager.h
  group framework/MemManager/Source
    framework/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    framework/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    framework/Messaging/Source/: Messaging.c
  group framework/ModuleInfo
    framework/ModuleInfo/: ModuleInfo.c ModuleInfo.h
  group framework/MWSCoexistence/Interface
    framework/MWSCoexistence/Interface/: MWS.h
  group framework/MWSCoexistence/Source
    framework/MWSCoexistence/Source/: MWS.c
  group framework/NVM/Interface
    framework/NVM/Interface/: NVM_Interface.h
  group framework/NVM/Source
    framework/NVM/Source/: NV_Flash.c NV_Flash.h NV_FsciCommands.c NV_FsciCommands.h
  group framework/OSAbstraction/Interface
    framework/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group framework/OSAbstraction/Source
    framework/OSAbstraction/Source/: fsl_os_abstraction_bm.c
  group framework/Panic/Interface
    framework/Panic/Interface/: Panic.h
  group framework/Panic/Source
    framework/Panic/Source/: Panic.c
  group framework/Reset
    framework/Reset/: Reset.c
  group framework/RNG/Interface
    framework/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    framework/RNG/Source/: RNG.c
  group framework/SecLib
    framework/SecLib/: SecLib.c SecLib.h
  group framework/SerialManager/Interface
    framework/SerialManager/Interface/: SerialManager.h
  group framework/SerialManager/Source
    framework/SerialManager/Source/: SerialManager.c
  group framework/SerialManager/Source/I2C_Adapter
    framework/SerialManager/Source/I2C_Adapter/: I2C_Adapter.c I2C_Adapter.h
  group framework/SerialManager/Source/SPI_Adapter
    framework/SerialManager/Source/SPI_Adapter/: SPI_Adapter.c SPI_Adapter.h
  group framework/SerialManager/Source/UART_Adapter
    framework/SerialManager/Source/UART_Adapter/: UART_Adapter.c UART_Adapter.h
  group framework/Shell/Interface
    framework/Shell/Interface/: shell.h shell_config.h
  group framework/Shell/Source
    framework/Shell/Source/: shell.c shell_autocomplete.c shell_cmdhelp.c shell_cmdhist.c
  group framework/TimersManager/Interface
    framework/TimersManager/Interface/: TimersManager.h
  group framework/TimersManager/Source
    framework/TimersManager/Source/: TimersManager.c TimersManagerInternal.h TMR_Adapter.c TMR_Adapter.h
  group framework/XCVR/MKW41Z4
    framework/XCVR/MKW41Z4/: dbg_ram_capture.c dbg_ram_capture.h fsl_xcvr.c fsl_xcvr.h fsl_xcvr_trim.c fsl_xcvr_trim.h ifr_radio.c ifr_radio.h
  group framework/XCVR/MKW41Z4/cfgs_kw4x_3x_2x
    framework/XCVR/MKW41Z4/cfgs_kw4x_3x_2x/: fsl_xcvr_ant_config.c fsl_xcvr_ble_config.c fsl_xcvr_common_config.c fsl_xcvr_gfsk_bt_0p3_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p32_config.c fsl_xcvr_gfsk_bt_0p5_h_0p5_config.c fsl_xcvr_gfsk_bt_0p5_h_0p7_config.c fsl_xcvr_gfsk_bt_0p5_h_1p0_config.c fsl_xcvr_gfsk_bt_0p7_h_0p5_config.c fsl_xcvr_mode_datarate_config.c fsl_xcvr_msk_config.c fsl_xcvr_zgbe_config.c
  group source
    source/: app_config.c app_preinclude.h gatt_db.h gatt_uuid128.h wireless_uart.c wireless_uart.h
  group source/common
    source/common/: ApplMain.c ApplMain.h ble_conn_manager.c ble_conn_manager.h ble_controller_task.c ble_controller_task_config.h ble_host_task_config.h ble_host_tasks.c ble_init.c ble_init.h ble_service_discovery.c ble_service_discovery.h ieee11073.h
  group source/common/gatt_db
    source/common/gatt_db/: gatt_database.c gatt_db_handles.h
  group source/common/gatt_db/macros
    source/common/gatt_db/macros/: gatt_alloc_x.h gatt_db_macros.h gatt_db_x_macros.h gatt_decl_x.h gatt_enum_x.h gatt_init_x.h gatt_size_x.h gatt_uuid_decl_x.h gatt_uuid_def_x.h
  group utilities
    utilities/: fsl_debug_console.c fsl_debug_console.h
